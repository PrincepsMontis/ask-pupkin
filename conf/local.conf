## conf/local.conf
```bitbake
[ask_pupkin]
SECRET_KEY = 'django-insecure-w1#qh5pjo$q82u-@d-x(=6cooll-$7kp!3dum!(uhnq-==gyb)'
```
